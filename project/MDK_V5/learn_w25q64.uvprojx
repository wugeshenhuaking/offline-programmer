# Keil uVision project learn_w25q64.uvprojx, settings and files
target learn_w25q64 (6230000::V6.23::ARMCLANG)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: learn_w25q64 +hex
  AfterMake: D:\CodeProjects\AT32IDE_Proj\learn_w25q64\project\MDK_V5\keil-build-viewer.exe
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AT32F403ARGT7, USE_STDPERIPH_DRIVER, AT_START_F403A_V1
  c include: ..\..\libraries\drivers\inc;..\..\libraries\cmsis\cm4\core_support;..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\bsp;../../middlewares/usbd_drivers/inc;..\..\DAP;..\..\algo;..\..\DAP_Config;..\..\user_task;..\..\component\agile_modbus\inc;..\..\component\agile_modbus\util;../../middlewares/3rd_party/fatfs/source;../../middlewares/freertos/source/include;../../middlewares/freertos/source/portable/memmang;../../middlewares/freertos/source/portable/GCC/ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ../src/: main.c at32f403a_407_wk_config.c at32f403a_407_int.c wk_system.c freertos_app.c include_port.c wk_debug.c wk_spi.c wk_usart.c wk_gpio.c usb_app.c wk_acc.c wk_usbfs.c diskio.c fatfs_disk.c user_diskio.c wk_dma.c rtc.c
  group firmware
    ../../libraries/drivers/src/: at32f403a_407_crm.c at32f403a_407_tmr.c at32f403a_407_rtc.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_usart.c at32f403a_407_pwc.c at32f403a_407_adc.c at32f403a_407_spi.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_crc.c at32f403a_407_wwdt.c at32f403a_407_wdt.c at32f403a_407_exint.c at32f403a_407_misc.c at32f403a_407_usb.c at32f403a_407_acc.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_xmc.c at32f403a_407_emac.c at32f403a_407_sdio.c at32f403a_407_debug.c at32f403a_407_bpr.c
  group cmsis
    ./: startup_at32f403a_407.s
    ../../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group usbd_class
    ../src/: msc_diskio.c msc_class.c msc_desc.c msc_bot_scsi.c
  group middlewares/usbd_driver
    ../../middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
  group component/agile_modbus
    ../../component/agile_modbus/src/: agile_modbus.c agile_modbus_rtu.c agile_modbus_tcp.c
    ../../component/agile_modbus/util/: agile_modbus_slave_util.c agile_modbus_slave_util.h
  group SWD
    ../../DAP_Config/: SWD_flash.c SWD_host.c
  group DAP
    ../../DAP/: SW_DP.c DAP.c
  group ALGO
    ../../algo/: AT32F415_128.c
  group bsp/25qx
    ../../bsp/bsp_25qxx/: bsp_25qxx.c bsp_25qxx.h bsp_25qxx_msp.c
  group bsp/usart
    ../../bsp/bsp_usart/: bsp_usart.c bsp_usart.h
  group user_task
    ../../user_task/: log.h user_task.c
  group user_task/task_programmer
    ../../user_task/task_programmer/: task_programmer.c task_programmer.h
  group user_task/task_modbus
    ../../user_task/task_modbus/: task_modbus_communication.c task_modbus_communication.h bits.c input_bits.c input_registers.c registers.c
  group middlewares/fatfs
    ../../middlewares/3rd_party/fatfs/source/: ff.c ffsystem.c ffunicode.c
  group middlewares/freertos
    ../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c stream_buffer.c
    ../../middlewares/freertos/source/portable/memmang/: heap_4.c
